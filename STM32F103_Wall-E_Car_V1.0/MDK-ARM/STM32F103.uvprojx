# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;        ../Drivers/CMSIS/Include;        ..\App;        ..\..\STM32_Liyao_Frame\Frame;        ..\Device;        ..\Device\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group App
    ../App/: FrameConfig.h Protocol.c Protocol.h ProtocolHandle.c ProtocolHandle.h
  group Frame
    ../../STM32_Liyao_Frame/Frame/: ComBuff.c ComBuff.h List.c List.h LOG.c LOG.h ProtocolFrame.c ProtocolFrame.h Queue.c Queue.h TaskTimeManager.c TaskTimeManager.h
  group Device
    ../Device/: MotorControl.c MotorControl.h PID.c PID.h Strategy.c Strategy.h RudderControl.c RudderControl.h UltrasonicControl.c UltrasonicControl.h
  group Device/OLED
    ../Device/OLED/: bmp.h oled.c oled.h oledfont.h
  group Application/User
    ../Src/: main.c usart.c dma.c tim.c stm32f1xx_hal_msp.c stm32f1xx_it.c gpio.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash.c stm32f1xx_hal.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pwr.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
software components: CMSIS:CORE 4.1.0
