# IAR project STM32F103.ewp, settings and files
configuration STM32F103 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\..\STM32_Liyao_Frame\Frame; ..\App; ..\HeadWingMotor
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103.bin
  ILINK.IlinkOutputFile: STM32F103.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/App
    ../App/: FrameConfig.h Protocol.c Protocol.h ProtocolHandle.c ProtocolHandle.h
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
  group Application/Frame
    ../../STM32_Liyao_Frame/Frame/: ComBuff.c ComBuff.h List.c List.h LOG.c LOG.h ProtocolFrame.c ProtocolFrame.h Queue.c Queue.h TaskTimeManager.c TaskTimeManager.h
  group Application/HeadWingMotor
    ../App/: MotorDriver.c MotorDriver.h
    ../HeadWingMotor/: MotorHeadDriver.c MotorHeadDriver.h MotorWingDriver.c MotorWingDriver.h PID.c PID.h
  group Application/User
    ../Src/: dma.c gpio.c i2c.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c
    ../Inc/: main.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
