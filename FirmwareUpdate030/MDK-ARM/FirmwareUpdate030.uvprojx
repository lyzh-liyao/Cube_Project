# Keil uVision project FirmwareUpdate030.uvprojx, settings and files
target FirmwareUpdate030 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: FirmwareUpdate030
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F030xC,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F0xx_HAL_Driver/Inc;   ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;   ../Drivers/CMSIS/Include;   D:\LiyaoProject\Cube_Project\STM32_Liyao_Frame\Frame;   D:\LiyaoProject\Cube_Project\STM32_Liyao_Frame\BootloaderFrame
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c gpio.c usart.c
  group Application/MDK-ARM
    ./: startup_stm32f030xc.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_dma.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c stm32f0xx_ll_gpio.c stm32f0xx_ll_exti.c stm32f0xx_ll_rcc.c stm32f0xx_ll_pwr.c
  group Frame
    D:/LiyaoProject/Cube_Project/STM32_Liyao_Frame/BootloaderFrame/: FirmwareUpdate.c FirmwareUpdate.h iap.c iap.h
    D:/LiyaoProject/Cube_Project/STM32_Liyao_Frame/Frame/: Queue.c Queue.h LOG.c LOG.h
software components: CMSIS:CORE 4.1.0
