# Keil uVision project STM32F030F4_BASE_V1.0.uvprojx, settings and files
target STM32F030F4_BASE_V1.0 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F030F4_BASE_V1.0
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;                                                                            ../Drivers/STM32F0xx_HAL_Driver/Inc;                                                                            ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                                                            ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                                                            ../Drivers/CMSIS/Include;                                                                            ..\App;                                                                            ..\..\STM32_Liyao_Frame\Frame
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c main.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c dma.c adc.c tim.c
  group App
    ../App/: FrameConfig.h Protocol.c Protocol.h ProtocolHandle.c ProtocolHandle.h UltrasonicDriver.c UltrasonicDriver.h InfraredDriver.c InfraredDriver.h
  group Frame
    ../../STM32_Liyao_Frame/Frame/: ComBuff.c ComBuff.h List.c List.h LOG.c LOG.h Queue.c Queue.h ProtocolFrame.c ProtocolFrame.h TaskTimeManager.c TaskTimeManager.h ChipTools.c ChipTools.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_pwr.c stm32f0xx_hal.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_ll_exti.c stm32f0xx_ll_utils.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
software components: CMSIS:CORE 4.1.0
